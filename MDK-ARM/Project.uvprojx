# Keil uVision project Project.uvprojx, settings and files
target Target (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SW-101-PYB_Board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Ax5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\Drivers\BSP\PY32F002xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f002xx.s
  group Application/User
    ../Src/: main.c py32f0xx_it.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_gpio.c py32f0xx_ll_tim.c py32f0xx_ll_exti.c py32f0xx_ll_rcc.c py32f0xx_ll_pwr.c py32f0xx_ll_utils.c
  group Devices
    ../Src/: oled091.c t_iic.c
  group Doc
    ../: readme.txt
